require u-boot-common.inc
require u-boot.inc

LICENSE = "GPL-2.0-or-later"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=2ca5f2c35c8cc335f0a19756634782f1"

SRCREV = "05aa6516c6bb419d01d69fac457c0de563bfd694"

DEPENDS += "bc-native dtc-native python3-setuptools-native"

